# Keil uVision project DSP.uvprojx, settings and files
target STM32F4xx-Nucleo (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xx-Nucleo
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,ARM_MATH_CM4,__FPU_PRESENT =1
  c misc: --C99
  c include: ..\LIB\Inc\CMSIS;..\LIB\Inc\HAL;..\USER\Inc;..\STARTUP;..\DSP\include;..\HARDWARE\Serial;..\SYS;..\HARDWARE\LED;..\HARDWARE\LCD1602A
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group HARDWARE
    ../HARDWARE/LED/: led.c
  group STARTUP
    ../STARTUP/: startup_stm32f401xe.s system_stm32f4xx.c
  group USER
    ../USER/Src/: retarget_usart.c
    ../HARDWARE/Serial/: Serial.c
    ../SYS/: sys.c
  group DSP
    ../DSP/src/: arm_abs_f32_test.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.80.0
