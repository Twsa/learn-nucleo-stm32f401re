# Keil uVision project CMSIS_DbgFunc.uvprojx, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS_DbgFunc
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./: startup_stm32f10x_md.s system_stm32f10x.c core_cm3.c
  group Source Files
    ./: CMSIS_DbgFunc.c Retarget.c
  group Documentation
    ./: Abstract.txt
target STM32F103 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: as above
  output: CMSIS_DbgFunc
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 4.3.0
