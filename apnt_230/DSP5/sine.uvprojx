# Keil uVision project sine.uvprojx, settings and files
target ST Link Flash (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: sine
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM4 __DBG_ITM  HSE_VALUE=8000000
  c include: .\include;.\src;.\RTE;.\RTE\Device\STM32F407VG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./src/: DirtyFilter.c sine_generator.c low_pass_filter.c Retarget.c
  group Device-STM32F4
    ./: Serial_STM32F4.c abstract.txt
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.80.0, Device:Startup 2.6.0
